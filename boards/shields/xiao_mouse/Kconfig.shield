## config/boards/shields/xiao_mouse/Kconfig.defconfig
```kconfig
if SHIELD_XIAO_MOUSE

config ZMK_KEYBOARD_NAME
	default "XIAO Mouse"

endif # SHIELD_XIAO_MOUSE
```
